# Keil uVision project g2fd.uvprojx, settings and files
target g2fd (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: AT32F456ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: g2fd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F456RET7,USE_STDPERIPH_DRIVER,AT_START_F456_V1
  c include: ..\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\libraries\drivers\inc;..\middlewares\usb_drivers\inc;..\middlewares\usbd_class\winusb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\g2fd.sct
  group user
    ../src/: at32f45x_int.c at32f45x_clock.c main.c bsp_can.c led.c bsp_usb.c gs_usb_protocol.c bsp_can_init.c can_ring.c
  group bsp
    ../src/: at32f45x_board.c
  group firmware
    ../libraries/drivers/src/: at32f45x_gpio.c at32f45x_misc.c at32f45x_crm.c at32f45x_usart.c at32f45x_tmr.c at32f45x_dma.c at32f45x_adc.c at32f45x_can.c at32f45x_pwc.c at32f45x_flash.c at32f45x_usb.c at32f45x_acc.c at32f45x_exint.c at32f45x_scfg.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f45x.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
  group usbd_driver
    ../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../middlewares/usbd_class/winusb/: winusb_class.c winusb_desc.c
